
do_install_append(){
    install -d ${datadir}/misc/magic 
}
